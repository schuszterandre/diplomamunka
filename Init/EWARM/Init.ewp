# IAR project Init.ewp, settings and files
configuration Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303CB ST STM32F303CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Init.out
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Application/EWARM
    ./:  startup_stm32f303xc.s
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ./: 
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c
